# Keil uVision project 2-5-独立按键控制亮灭.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89F52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: 2-5-独立按键控制亮灭
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
